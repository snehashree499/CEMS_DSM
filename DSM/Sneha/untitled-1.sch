v {xschem version=3.4.6 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {SRLatch_Comparator.sym} -40 -20 0 0 {name=x1}
